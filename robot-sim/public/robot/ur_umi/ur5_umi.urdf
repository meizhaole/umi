Commit message: feat(robot-sim): 调整 UMI 视觉安装位姿

File: robot-sim/public/robot/ur_umi/ur5_umi.urdf (robot description, URDF)
Before this commit: robot ur5_umi, 16 links, 15 joints
Joints:
- joint ur5_to_umi_mount: origin xyz=0 0 0 rpy=0 0 0 -> xyz=0 0 0.08 rpy=0 0 1.5707963267948966
